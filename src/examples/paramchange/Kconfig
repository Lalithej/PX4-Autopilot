## src/examples/paramchange/Kconfig
```kconfig
menuconfig EXAMPLES_PARAMCHANGE
	bool "paramchange"
	default n
	---help---
		Enable support for paramchange
```
